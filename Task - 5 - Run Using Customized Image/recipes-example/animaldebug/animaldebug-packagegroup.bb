DESCRIPTION = "A friendly program for packagegroup"
inherit packagegroup

PACKAGES = "\ 
packagegroup-debug1 \ 
packagegroup-debug2 \ 
packagegroup-debug3 \
"
RDEPENDS_packagegroup-debug1 = "\ 
helloworld \
animaldebug1 \
"
RDEPENDS_packagegroup-debug2 = "\ 
helloworld \
animaldebug2 \
"
RDEPENDS_packagegroup-debug3 = "\ 
helloworld \
animaldebug3 \
"

