CORE_IMAGE_EXTRA_INSTALL_append= "\ 
packagegroup-debug1 \ 
" 

